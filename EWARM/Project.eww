<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bootcamp_v2_pwm_led_adjustable.ewp</path>
  </project>
  <batchBuild />
</workspace>
